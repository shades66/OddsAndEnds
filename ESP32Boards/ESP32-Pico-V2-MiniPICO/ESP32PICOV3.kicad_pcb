# Repository shades66/OddsAndEnds

File README.md:

# OddsAndEnds
Just odds and ends I've saved for a rainy day

markisol.h  - ESPHome library to allow use of BOFU  BF-301  controlled blinds via RF transmitter

Philips-LivingColours-GEN2.jpeg  - PCB from an old Philips LivingColours lamp which we have long since lost the remote for.  Modified to work as part of my ESPHome setup.   See key on image for the locations of the various control pins,  I mounted a M5Stack Pico over the location the original CPU sat and ran wires to the 4 gpios for RED/GREEN/BLUE & Enable (as far as I can tell enables the powersupply section that feeds the LED's).  I did try using the 3v feed that fed the microprocessor but it was not enough for the ESP32 to powerup.  instead I used a mini buck converter with the inputs from a capacitor connected to the Power in port (18 Volts!!) which provided a 5v feed for the pico.

LivingColours.yaml  - ESPHome config for the above circuit.  See pins defined for the connections I made on the PCB.  This setup is the basic rgb light config with two extras for on_turn_on/on_turn_off which switch the enable pin high/low.

ESPHome/clockhacking - Hacking a cheap AliExpress clock to work via ESPHome.

## KiCad design ESP32Boards/ESP32-Pico-V2-MiniPICO/ESP32PICOV3.kicad_pcb

File ESP32Boards/README.txt:

(Best viewed as raw to get the formatting.  broke when I created it :(  )

 Some of the boards I've been making for use a base boards for various Home Assistant & Other odds and ends

Folders are

CH340-Programmer  -  Board that contains the pins that match up with the pins on the V1.1 & V2 boards for programming
USB-C-Board  - Small board for holding a USB C SMD connector / related 5.1k resistors & header for 4 pins to other boards like the CH340 programmer & V1.1 board
V1  - ESP32 WROVER based board includes on board CH340 chip for programming ,   
         pins for connecting LED strips & badly aligned headers for other external devices  (sensors, transeivers etc)
V1.1 - ESP32 WROVER based revision of V1 to make smaller,    
         Corrected header alignments,   
         USB now via 4 pin header,  
         header for CH340 programmer or can add a CH340 & components to the bottom,  
         + 6 mini 2020 WS2812 Led's because why not...
V2 -   ESP32-S3 BASED (can use both S3-WROOM-1U & S3-WROOM-1 modules) 
        Complete re-vamp.  
        Connections now via 1.25mm JST connectors.  
          5x  4 pin  3.3v/GND/Dx/Dy format,  
          1x 4 pin  3.3v OR 5v/GND/Dx/Dy pinout (pin numbers on silkscreen),  
          1x 8 pin extra IO  3.3v/GND + 6IO - also available via 0.5mm Flex connector (compatible with corresponding connector on some TFT panels  eg https://www.aliexpress.com/item/1005003764841816.html )
          6pin 2mm header for programmer as V1.1
          1x 4pin 1.25mm  USB connection direct to S3 (via protection chip)
        Multiple power options
          1. USB Input pins   - 5v
          2. 2.54mm header (or can hold buck converter)   5v
          3. 2 pin into buck converter  5-24v
        3x3 matrix of 2020 WS2812 LED's
        2x LDO,   1 for just the ESP32 S3,  other for everything else so could be 5v if wanted (not with LIS3H though).  Can be joined so only 1 needs to be populated
        LIS3DH  MEMS digital output motion sensor / ultra-low-power high-performance 3-axis "nano" accelerometer   https://www.st.com/resource/en/datasheet/lis3dh.pdf
        **  Recommend getting a stencil for this one.   lots of small components/pins (on the LIS3dh)
  ESP32-Pico-V2-MiniPICO - ESP32 PICO V3 Based board for putting in tiny spaces
        My first 4 layer board. and it appears to work....
        2x3 connector for programming adapter
        8 pin connector for power & 5 IO pins
        Can be driven via 3.3v or 5v via LDO
        Uses external antenna via IPEX socket.   not tuned at-all but works so far with values shown on bom/schematic.   Need to get a VNA to work out ideal values.

Files in these directories supplied with no warranty whatsoever.  They are just backups of boards I have created,  V2 has interactive BOM,  Files work in KiCad 7,   zip files supplied which is what I sent to JLCPCB to have produced.   They are single boards only, panelized within JLCPCB web interface.

Parts:
AE1: Antenna; U.FL_Hirose_U.FL-R-SMT-1_Vertical
C1, C8, C9, C11: 1uF; C_0402_1005Metric
C2, C3: 1.5pF; C_0402_1005Metric
C4, C5, C10, C12, C13: 100nF; C_0402_1005Metric
C6, C7: 10uF; C_0603_1608Metric
D1: WS2812B; WS2812_2020
D2, D3: LED; LED_0603_1608Metric
J1: Conn_02x03_Odd_Even; PinHeader_2x03_P2.00mm_Vertical
J2: Conn_01x08_Socket; Hirose_DF13-08P-1.25DSA_1x08_P1.25mm_Vertical
L1: 1.8nH; L_0603_1608Metric
R1: 10K; R_0402_1005Metric
R2: 47R; R_0402_1005Metric
R3, R4: 330R; R_0402_1005Metric
U1: ESP32-PICO-V3; QFN-48-1EP_7x7mm_P0.5mm_EP5.15x5.15mm
U3: AP2112K-3.3; SOT-23-5

Connections:
+3V3: C4.1, C5.1, C6.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, D1.1 (VDD), J1.1, J2.1, R1.1, R3.1, U1.1 (VDDA), U1.3 (VDD3P3), U1.4 (VDD3P3), U1.19 (VDD3P3_RTC), U1.37 (VDD3P3_CPU), U1.43 (VDDA), U1.46 (VDDA), U3.5 (VOUT)
+5V: C7.1, J2.2, U3.1 (VIN), U3.3 (EN)
GND: AE1.2 (Shield), C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D1.3 (VSS), D2.1 (K), D3.1 (K), J1.2, J2.8, U1.49 (GND), U3.2 (GND)
unnamed: AE1.1 (A), C3.2, L1.2
unnamed: D1.4 (DIN), R2.2
unnamed: D2.2 (A), R3.2
unnamed: D3.2 (A), R4.2
unnamed: J1.3, U1.40 (U0RXD/GPIO3)
unnamed: J1.4, U1.23 (GPIO0/BOOT/ADC2_CH1)
unnamed: J1.5, U1.41 (U0TXD/GPIO1)
unnamed: C1.1, J1.6, R1.2, U1.9 (CHIP_PU)
unnamed: J2.3, U1.14 (GPIO25/ADC2_CH8/DAC_1)
unnamed: J2.4, U1.15 (GPIO26/ADC2_CH9/DAC_2)
unnamed: J2.5, U1.16 (GPIO27/ADC2_CH7)
unnamed: J2.6, U1.17 (MTMS/GPIO14/ADC2_CH6)
unnamed: J2.7, U1.27 (GPIO20)
unnamed: R4.1, U1.24 (GPIO4/ADC2_CH0)
unnamed: R2.1, U1.34 (GPIO5)
unnamed: C2.2, L1.1, U1.2 (LNA_IN)

Board: 4 copper layers, 29.3 x 12.1 mm, 26 parts (1 on the bottom side), 19 nets.

## KiCad design ESP32Boards/V2/esp32-s3-dev.kicad_pcb

File ESP32Boards/README.md:

(Best viewed as raw to get the formatting.  broke when I created it :(  )

 Some of the boards I've been making for use a base boards for various Home Assistant & Other odds and ends

Folders are

CH340-Programmer  -  Board that contains the pins that match up with the pins on the V1.1 & V2 boards for programming
USB-C-Board  - Small board for holding a USB C SMD connector / related 5.1k resistors & header for 4 pins to other boards like the CH340 programmer & V1.1 board
V1  - ESP32 WROVER based board includes on board CH340 chip for programming ,   
         pins for connecting LED strips & badly aligned headers for other external devices  (sensors, transeivers etc)
V1.1 - ESP32 WROVER based revision of V1 to make smaller,    
         Corrected header alignments,   
         USB now via 4 pin header,  
         header for CH340 programmer or can add a CH340 & components to the bottom,  
         + 6 mini 2020 WS2812 Led's because why not...
V2 -   ESP32-S3 BASED (can use both S3-WROOM-1U & S3-WROOM-1 modules) 
        Complete re-vamp.  
        Connections now via 1.25mm JST connectors.  
          5x  4 pin  3.3v/GND/Dx/Dy format,  
          1x 4 pin  3.3v OR 5v/GND/Dx/Dy pinout (pin numbers on silkscreen),  
          1x 8 pin extra IO  3.3v/GND + 6IO - also available via 0.5mm Flex connector (compatible with corresponding connector on some TFT panels  eg https://www.aliexpress.com/item/1005003764841816.html )
          6pin 2mm header for programmer as V1.1
          1x 4pin 1.25mm  USB connection direct to S3 (via protection chip)
        Multiple power options
          1. USB Input pins   - 5v
          2. 2.54mm header (or can hold buck converter)   5v
          3. 2 pin into buck converter  5-24v
        3x3 matrix of 2020 WS2812 LED's
        2x LDO,   1 for just the ESP32 S3,  other for everything else so could be 5v if wanted (not with LIS3H though).  Can be joined so only 1 needs to be populated
        LIS3DH  MEMS digital output motion sensor / ultra-low-power high-performance 3-axis "nano" accelerometer   https://www.st.com/resource/en/datasheet/lis3dh.pdf
        **  Recommend getting a stencil for this one.   lots of small components/pins (on the LIS3dh)

Files in these directories supplied with no warranty whatsoever.  They are just backups of boards I have created,  V2 has interactive BOM,  Files work in KiCad 7,   zip files supplied which is what I sent to JLCPCB to have produced.   They are single boards only, panelized within JLCPCB web interface.

Parts:
C1, C2, C3, C4: 10uF; C_0805_2012Metric
C5, C6, C7, C8, C10: 10uF; C_0603_1608Metric
C9, C11: 100nF; C_0603_1608Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9: WS2812B; WS2812_2020
D10, D11: LED; LED_0603_1608Metric
J1: Conn_01x06_Pin; PinHeader_1x06_P2.00mm_Vertical
J2, J7, J8, J9, J10, J11: Conn_01x04_Pin; Hirose_DF13-04P-1.25DSA_1x04_P1.25mm_Vertical
J3: Conn_01x08; Hirose_FH12-8S-0.5SH_1x08-1MP_P0.50mm_Horizontal
J4: Conn_01x08; Hirose_DF13-08P-1.25DSA_1x08_P1.25mm_Vertical
J5: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_Pad1.0x1.5mm
JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R3, R4: 10k; R_0603_1608Metric
R5, R6: 330; R_0603_1608Metric
SW1, SW2: SW_Push; TS-1224VW
U1: USBLC6-2SC6; SOT-23-6
U2: ESP32-S3-WROOM-1; ESP32-S3-WROOM-1U
U3, U4: AMS1117-3.3; SOT-89-3
U5: LIS3DH; LGA-16_3x3mm_P0.5mm_LayoutBorder3x5y

Connections:
+3.3VP: C4.1, C5.1, C6.1, C7.1, C10.2, C11.2, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), J3.2, J4.2, J7.1, J8.1, J9.1, J11.1, JP1.1 (A), JP2.1 (A), R2.1, R3.1, R4.1, R6.1, U4.2 (VO), U5.1 (VDD_IO), U5.14 (VDD)
+3V3: C2.1, C8.1, C9.1, J1.6, JP1.2 (B), R1.1, R5.1, U2.2 (3V3), U3.2 (VO)
/BOOT: J1.3, SW1.1, U2.27 (GPIO0/BOOT)
/EN: J1.2, R1.2, SW2.1, U2.3 (EN)
/GPIO1: J7.3, U2.39 (GPIO1/TOUCH1/ADC1_CH0)
/GPIO2: J7.4, U2.38 (GPIO2/TOUCH2/ADC1_CH1)
/GPIO3: D1.4 (DIN), U2.15 (GPIO3/TOUCH3/ADC1_CH2)
/GPIO4: J11.4, U2.4 (GPIO4/TOUCH4/ADC1_CH3)
/GPIO5: J3.7, J4.7, U2.5 (GPIO5/TOUCH5/ADC1_CH4)
/GPIO6: J11.3, U2.6 (GPIO6/TOUCH6/ADC1_CH5)
/GPIO7: J9.4, U2.7 (GPIO7/TOUCH7/ADC1_CH6)
/GPIO8: R4.2, U2.12 (GPIO8/TOUCH8/ADC1_CH7/SUBSPICS1), U5.4 (SCL/SPC)
/GPIO9: R3.2, U2.17 (GPIO9/TOUCH9/ADC1_CH8/FSPIHD/SUBSPIHD), U5.6 (SDA/SDI/SDO)
/GPIO10: U2.18 (GPIO10/TOUCH10/ADC1_CH9/FSPICS0/FSPIIO4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), U5.11 (INT1)
/GPIO11: U2.19 (GPIO11/TOUCH11/ADC2_CH0/FSPID/FSPIIO5/S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), U5.9 (INT2)
/GPIO14: J3.3, J4.3, U2.22 (GPIO14/TOUCH14/ADC2_CH3/FSPIWP/FSPIDQS/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)
/GPIO15: J3.4, J4.4, U2.8 (GPIO15/U0RTS/ADC2_CH4/XTAL_32K_P)
/GPIO16: J9.3, U2.9 (GPIO16/U0CTS/ADC2_CH5/XTAL_32K_N)
/GPIO17: J10.4, U2.10 (GPIO17/U1TXD/ADC2_CH6)
/GPIO18: J10.3, U2.11 (GPIO18/U1RXD/ADC2_CH7/CLK_OUT3)
/GPIO21: J3.5, J4.5, U2.23 (GPIO21)
/GPIO38: J3.8, J4.8, U2.31 (GPIO38/FSPIWP/SUBSPIWP)
/GPIO39: J3.6, J4.6, U2.32 (MTCK/GPIO39/CLK_OUT3/SUBSPICS1)
/GPIO40: J8.4, U2.33 (MTDO/GPIO40/CLK_OUT2)
/GPIO41: J8.3, U2.34 (MTDI/GPIO41/CLK_OUT1)
/VIN: J5.2, J6.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.1, C11.1, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.1 (K), D11.1 (K), J1.1, J2.1, J3.1, J4.1, J5.3, J6.1, J7.2, J8.2, J9.2, J10.2, J11.2, SW1.2, SW2.2, U1.2 (GND), U2.1 (GND), U2.40 (GND), U2.41 (GND), U3.1 (GND), U4.1 (GND), U5.5 (GND), U5.7 (SDO/SA0), U5.10 (GND), U5.12 (GND)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D8.2 (DOUT), D9.4 (DIN)
unnamed: D10.2 (A), R5.2
unnamed: D11.2 (A), R6.2
unnamed: J1.4, U2.37 (U0TXD/GPIO43/CLK_OUT1)
unnamed: J1.5, U2.36 (U0RXD/GPIO44/CLK_OUT2)
unnamed: J2.2, U1.4 (I/O2)
unnamed: J2.3, U1.6 (I/O1)
unnamed: J10.1, JP2.2 (C)
unnamed: U1.3 (I/O2), U2.13 (GPIO19/U1RTS/ADC2_CH8/CLK_OUT2/USB_D-)
unnamed: U1.1 (I/O1), U2.14 (GPIO20/U1CTS/ADC2_CH9/CLK_OUT1/USB_D+)
unnamed: R2.2, U5.8 (CS)
VBUS: C1.1, C3.1, J2.4, J5.4, JP2.3 (B), U1.5 (VBUS), U3.3 (VI), U4.3 (VI)

Board: 2 copper layers, 46.6 x 32.7 mm, 48 parts (0 on the bottom side), 46 nets.

## KiCad design ESP32Boards/USB-C-Board/lcd.kicad_pcb

Board: 2 copper layers, 15.1 x 16.2 mm, 4 parts (0 on the bottom side), 6 nets.

Parts:
J1: USB_C_Receptacle; USB_C_Receptacle_Palconn_UTC16-G
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
R12, R15: 5.1k; R_0805_2012Metric

Connections:
/D+: J1.A6, J1.B6, J2.2
/D-: J1.A7, J1.B7, J2.3
GND: J1.A1, J1.A12, J1.B1, J1.B12, J1.S1, J2.4, R12.2, R15.2
unnamed: J1.A5, R12.1
unnamed: J1.B5, R15.1
VBUS: J1.A4, J1.A9, J1.B4, J1.B9, J2.1

## KiCad design ESP32Boards/V1/lcd.kicad_pcb

Parts:
C2, C4, C5, C15: 1uF; C_0805_2012Metric
C3: 100pf; C_0805_2012Metric
C6, C11: 10uF; C_0805_2012Metric
D6, D7: LED; LED_0603_1608Metric
J1: USB_C_Receptacle; USB_C_Receptacle_Palconn_UTC16-G
J2: Conn_02x08_Counter_Clockwise; PinHeader_2x08_P2.54mm_Vertical
J3: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
J4: Conn_01x04_Male; PinHeader_1x04_P1.27mm_Vertical
J5: Conn_02x04_Odd_Even; PinHeader_2x04_P1.27mm_Vertical
J6: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
JP1, JP2, JP3: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1, Q2: S8050-Transistor_BJT; SOT-23
R2, R10, R11: 10k; R_0805_2012Metric
R12, R15: 5.1k; R_0805_2012Metric
R13, R14: 220r; R_0805_2012Metric
SW1, SW2: SW_Push; SW_SPST_CK_RS282G05A3
U1: ESP32-WROVER; ESP32-WROVER-smallfeet
U2: AP2112K-3.3; SOT-23-5
U5: CH340G; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C4.2, C5.2, C11.2, C15.1, D6.1 (K), D7.1 (K), J4.2, J5.2, JP1.1 (A), JP2.1 (A), R2.2, U1.2, U2.5 (VOUT), U5.4 (V3), U5.16 (VCC)
/BOOT: Q2.3 (C), SW2.1, U1.25
/ESP_EN: Q1.3 (C), R2.1, SW1.1, U1.3
/ESP_RXD: R14.1, U1.34, U5.2 (TXD)
/ESP_TXD: R13.1, U1.35, U5.3 (RXD)
/FT_DTR: Q2.2 (E), R10.1, U5.13 (~DTR)
/FT_RTS: Q1.2 (E), R11.1, U5.14 (~RTS)
/IO4: JP3.3 (B), U1.26
/IO5: J6.2, JP3.1 (A), U1.29
/IO12: J2.3, U1.14
/IO13: J2.1, U1.16
/IO14: J2.5, U1.13
/IO18: J5.6, U1.30
/IO19: J5.8, U1.31
/IO21: J4.3, J5.3, U1.33
/IO22: J4.4, J5.4, U1.36
/IO23: J5.7, U1.37
/IO25: J2.11, U1.10
/IO26: J2.9, U1.11
/IO27: J2.7, U1.12
/IO32: J2.15, U1.8
/IO33: J2.13, U1.9
/IO_CS: J5.5, JP3.2 (C)
GND: C2.1, C3.1, C4.1, C5.1, C6.1, C11.1, C15.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J4.1, J5.1, J6.3, R12.2, R15.2, SW1.2, SW2.2, U1.1, U1.15, U1.38, U2.2 (GND), U5.1 (GND)
unnamed: D6.2 (A), R13.2
unnamed: D7.2 (A), R14.2
unnamed: J1.A5 (CC1), R12.1
unnamed: J1.A6 (D+), J1.B6 (D+), U5.5 (UD+)
unnamed: J1.A7 (D-), J1.B7 (D-), U5.6 (UD-)
unnamed: J1.B5 (CC2), R15.1
unnamed: J3.1, J3.2, J3.3, J3.4, JP2.2 (C)
unnamed: J3.5, J3.6, J3.7, J3.8, JP1.2 (C)
unnamed: Q1.1 (B), R10.2
unnamed: Q2.1 (B), R11.2
VBUS: C2.2, C3.2, C6.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), J6.1, JP1.3 (B), JP2.3 (B), U2.1 (VIN), U2.3 (EN)

Notes on the sheet:
AUTO Programmer
Decoupling Caps
MiniESP32-V3
V0 13/03/2020 V1 21/07 V2 03/08 V3 12/09
USB Interface

Board: 2 copper layers, 42.8 x 45.7 mm, 32 parts (1 on the bottom side), 35 nets.

## KiCad design ESP32Boards/V1.1/lcd.kicad_pcb

Board: 2 copper layers, 42.8 x 40.5 mm, 36 parts (10 on the bottom side), 39 nets.

Parts:
C1, C3, C11: 10uF; C_0805_2012Metric
C2, C4, C5: 1uF; C_0805_2012Metric
D1, D2: LED; LED_0603_1608Metric
D3, D4, D5, D6, D7, D8: WS2812B; WS2812_2020
J1: Conn_01x07; PinHeader_1x07_P2.00mm_Vertical
J2: Conn_02x08_Counter_Clockwise; PinHeader_2x08_P2.54mm_Vertical
J3: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
J4: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J5: Conn_01x09_Male; PinHeader_1x09_P2.00mm_Vertical
J6: Conn_01x03_Male; PinHeader_1x03_P2.54mm_Vertical
JP1, JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4, JP5: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1, Q2: S8050; SOT-23-1and2-swapped
R1, R2, R3, R4, R5: 10k; R_0805_2012Metric
SW1, SW2: SW_Push; SW_SPST_CK_RS282G05A3
U1: ESP32-WROVER; ESP32-WROVER-smallfeet
U2: AP2112K-3.3; SOT-23-5
U3: CH340G; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C1.1, C3.2, C4.2, C5.2, C11.2, D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, J5.8, JP1.1, JP2.1, JP5.1, R2.2, U1.2, U2.5, U3.4, U3.16
/BOOT: J1.5, Q2.3, SW2.1, U1.25
/D+: J4.2, U3.5
/D-: J4.3, U3.6
/ESP_EN: J1.6, Q1.3, R2.1, SW1.1, U1.3
/ESP_RXD: J1.3, R5.1, U1.34, U3.2
/ESP_TXD: J1.4, R4.1, U1.35, U3.3
/FT_DTR: Q2.1, R1.1, U3.13
/FT_RTS: Q1.1, R3.1, U3.14
/IO4: J5.7, U1.26
/IO5: D3.4, J5.6, J6.2, U1.29
/IO12: J2.3, U1.14
/IO13: J2.1, U1.16
/IO14: J2.5, U1.13
/IO18: J5.5, U1.30
/IO19: J5.4, U1.31
/IO21: J5.3, U1.33
/IO22: J5.2, U1.36
/IO23: J5.1, U1.37
/IO25: J2.11, U1.10
/IO26: J2.9, U1.11
/IO27: J2.7, U1.12
/IO32: J2.15, U1.8
/IO33: J2.13, U1.9
GND: C1.2, C2.1, C3.1, C4.1, C5.1, C11.1, D3.3, D4.3, D5.3, D6.3, D7.3, D8.3, J1.7, J2.2, J2.4, J2.6, J2.8, J2.10, J2.12, J2.14, J2.16, J4.4, J5.9, J6.3, SW1.2, SW2.2, U1.1, U1.15, U1.38, U2.2, U3.1
unnamed: D1.2, R4.2
unnamed: D2.2, R5.2
unnamed: D3.2, D4.4
unnamed: D4.2, D5.4
unnamed: D5.2, D6.4
unnamed: D6.2, D7.4
unnamed: D7.2, D8.4
unnamed: J1.1, JP4.2
unnamed: J1.2, JP5.2
unnamed: J3.1, J3.2, J3.3, J3.4, JP2.2
unnamed: J3.5, J3.6, J3.7, J3.8, JP1.2
unnamed: Q1.2, R1.2
unnamed: Q2.2, R3.2
VBUS: C2.2, J4.1, J6.1, JP1.3, JP2.3, JP4.1, U2.1, U2.3

## KiCad design ESP32Boards/CH340-Programmer/lcd.kicad_pcb

Board: 2 copper layers, 39.3 x 16.4 mm, 17 parts (0 on the bottom side), 15 nets.

Parts:
C2, C5, C15: 1uF; C_0805_2012Metric
C3: 100pf; C_0805_2012Metric
C6: 10uF; C_0805_2012Metric
D6, D7: LED; LED_0603_1608Metric
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J4: Conn_01x07; PinHeader_1x07_P2.00mm_Vertical
Q1, Q2: S8050-Transistor_BJT; SOT-23
R10, R11: 10k; R_0805_2012Metric
R13, R14: 220r; R_0805_2012Metric
U2: AP2112K-3.3; SOT-23-5
U5: CH340G; SOIC-16_3.9x9.9mm_P1.27mm

Connections:
+3V3: C5.2, C15.1, D6.1, D7.1, J4.2, U2.5, U5.4, U5.16
/BOOT: J4.5, Q2.3
/D+: J2.2, U5.5
/D-: J2.3, U5.6
/ESP_EN: J4.6, Q1.3
/ESP_RXD: J4.3, R14.1, U5.2
/ESP_TXD: J4.4, R13.1, U5.3
/FT_DTR: Q2.2, R10.1, U5.13
/FT_RTS: Q1.2, R11.1, U5.14
GND: C2.1, C3.1, C5.1, C6.1, C15.2, J2.4, J4.7, U2.2, U5.1
unnamed: D6.2, R13.2
unnamed: D7.2, R14.2
unnamed: Q1.1, R10.2
unnamed: Q2.1, R11.2
VBUS: C2.2, C3.2, C6.2, J2.1, J4.1, U2.1, U2.3

## Commit log

2023-07-10 added PCB Bits
2023-07-10 added overview image
2025-02-19 Update README.txt
    added comments to code in readme
